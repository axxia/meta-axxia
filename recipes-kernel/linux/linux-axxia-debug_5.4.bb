require linux-axxia_${PV}.bb

LINUX_VERSION_EXTENSION = "-axxia-debug-${LINUX_KERNEL_TYPE}"
DBG = "yes"
