LINUX_KERNEL_TYPE = "preempt-rt"

require recipes-kernel/linux/linux-yocto.inc
require linux-axxia.inc
