require linux-yocto_4.19.bb

LINUX_VERSION_EXTENSION = "-axxia-debug-${LINUX_KERNEL_TYPE}"
DBG = "yes"
