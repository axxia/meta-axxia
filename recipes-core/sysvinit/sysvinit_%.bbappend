FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append = " file://0001-bootlogd-add-suport-for-custom-ttyAMA-console.patch"
