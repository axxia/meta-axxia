EXTRA_OECONF += "--without-openldap"
