FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://pseudo-fix-initializer-element-is-not-constant-error.patch"
